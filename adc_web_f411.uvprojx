# Keil uVision project adc_web_f411.uvprojx, settings and files
target ADC_Web_F411 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(16000000) ELITTLE
  output: adc_web +hex
  BeforeMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File ".\scripts\build_info.ps1"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE
  c misc: -std=c99 -Wall -Wextra -Werror -mfloat-abi=soft
  c include: .\src;.\third_party\CMSIS\Core\Include;.\third_party\STM32F4\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x80000
  scatter file: .\firmware\stm32f411.sct
  link misc: --strict
  group Application
    ./src/: main.c config.h
  group Board / CMSIS
    ./src/: startup_stm32f411.s board_i2c.c board.c help_store.c help_store.h help_seed.h flash_layout.h clock.c clock.h usart_console.c usart_console.h board.h
  group W5500
    ./src/: w5500.c w5500.h
  group HTTP
    ./src/: i2c_console.h i2c_console.c spi_console.c settings.c settings.h rtc.c rtc.h command_store.c command_store.h spi_console.h http.c http_parse.c http.h web_page.h
